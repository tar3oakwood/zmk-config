#include "../gravity36_xiao/gravity36_xiao.dtsi"

/ {
    chosen {
        zmk,kscan = &kscan_right; /* dtsi内に kscan_right を追加定義する */
        zmk,matrix_transform = &default_transform;
    };
};
